# Keil uVision project STM32F401xx.uvprojx, settings and files
target STM32F401xx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401xx +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\MDK-ARM\Output\STM32F401xx.bin ..\MDK-ARM\Output\STM32F401xx.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__RTX
  c misc: --C99
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\USER;..\..\SYSTEM\CONFIG;..\..\Libraries\FreeRTOS\include;..\..\Libraries\FreeRTOS\portable;..\..\SYSTEM\USART;..\..\SYSTEM\DELAY;..\..\SYSTEM\SYSCLOCK;..\..\SYSTEM\TASK;..\..\SYSTEM\NetWork-licheng;..\..\SYSTEM\LAN8720;..\..\Libraries\STM32F4xx_StdPeriph_Driver\STM32F4x7_ETH_Driver\inc;..\..\SYSTEM\Printf-usr;..\..\SYSTEM\TASK\TCP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group USER
    ../../USER/: main.c stm32f4xx_it.c usr_FreeRTOS.h globals.c
    ../../SYSTEM/CONFIG/: config.c
    ../../Libraries/FreeRTOS/include/: FreeRTOSConfig.h
  group Peripherals
    ../../SYSTEM/LAN8720/: lan8720.c
    ../../SYSTEM/SYSCLOCK/: Sysclock.c
    ../../SYSTEM/DELAY/: delay.c
    ../../SYSTEM/USART/: USART.c
  group TASK
    ../../SYSTEM/TASK/BSD/: BSD_socket_client.c BSD_socket_server.c
    ../../SYSTEM/TASK/TCP/: Tcp_client1.c Tcp_client2.c Tcp_server.c TCP_user.c
    ../../SYSTEM/TASK/UDP/: UDP_user.c
  group FreeRTOS/Source
    ../../Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../../Libraries/FreeRTOS/portable/: port.c portmacro.h heap_4.c
  group MDK-ARM
    ../../Libraries/CMSIS/: system_stm32f4xx.c
    ../../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group STM32_lib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../Libraries/STM32F4xx_StdPeriph_Driver/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group NetWork-licheng
    ../../SYSTEM/NetWork-licheng/: ETH_STM32F4xx.c ETH_STM32F4xx.h Net_Config.c Net_Debug.c Net_lib.c TCPD_CM3.lib
